# Keil uVision project 1910_1.uvproj, settings and files
target 1910_1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1910_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Driver;..\..\Sys
  group User
    ./: main.c
  group Sys
    ../../Sys/: timer.c
  group Driver
    ../../Driver/: bsp_iic.c bsp_init.c bsp_key.c bsp_led.c bsp_seg.c
