# Keil uVision project 210117713.uvproj, settings and files
target 210117713 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 210117713 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Deriver;..\User
  group User
    ../User/: main.c
  group Deriver
    ../Deriver/: ds1302.c ds1302.h onewire.c onewire.h smg_ca.c smg_ca.h
