# Keil uVision project 1607_1.uvproj, settings and files
target 1607_1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1607_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Driver;..\..\Sys
  group User
    ./: main.c
  group Sys
    ../../Driver/: bsp_init.c bsp_key.c bsp_led.c bsp_onewire.c bsp_seg.c
  group Driver
    ../../Sys/: timer.c
