# Keil uVision project 21011777.uvproj, settings and files
target 21011777 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 21011777 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Deriver;..\User
  group User
    ./: main.c
  group Deriver
    ../Deriver/: onewire.c
