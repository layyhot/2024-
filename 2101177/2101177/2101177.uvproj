# Keil uVision project 2101177.uvproj, settings and files
target 2101177 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2101177
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys;..\User
  group User
    ../User/: main.c
  group Sys
    ../Sys/: Timer.c Timer.h Usart.c Usart.h
  group Deriver
    ../Driver/: bsp_555_PWM_Freq.c bsp_555_PWM_Freq.h bsp_ds1302.c bsp_ds1302.h bsp_iic.c bsp_iic.h bsp_init.c bsp_init.h bsp_key.c bsp_key.h bsp_led.c bsp_led.h bsp_onewire.c bsp_onewire.h bsp_seg.c bsp_seg.h bsp_ultrasonic.c bsp_ultrasonic.h
